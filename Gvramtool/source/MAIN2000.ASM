; LIMIT$97FF (LZEを使う)
;LZEBUF 9800h～B7FFh (8192Bytes)
;FONT   9F80h～B7FFh (6272Bytes)
; LIMIT$B7FF (LZEを使わない)
;PRG    B800h～
;STACK  BF00h～BFFFh
;BUF    C000h～FE7Fh (8000/16000Bytes)
;GVRAM  C000h～FE7Fh (16000Bytes)

	ORG 0B800h
	; BASIC CALL ADDRESS
	JP	GVRAMTORAM			; USR($B800) GVRAM(16KB) → RAM BUF
	JP	RAMTOGVRAM_WIDTHX2		; USR($B803) BUF320x200(8KB) → GVRAM(640x200) 横2倍
	JP	RAMTOGVRAM			; USR($B806) BUF640x200(16KB) → GVRAM(640x200) MZ-2000専用
	LD	HL, 0				; POKE$B80A,L:POKE$B80B,H:USR($B809) LZE展開
	JP	DECORD
	JP	SD_USR_LOAD			; USR($B80F,F$) MZ2000_SDバイナリロード
	JP	SD_USR_OPEN_CONCAT		; USR($B812,F$) MZ2000_SD連結ファイルオープン
	JP	SD_READ_CONCAT_1BLOCK		; USR($B815)    MZ2000_SD連結ファイルロード
	JP	SD_SKIP_CONCAT_1BLOCK		; USR($B818)    MZ2000_SD連結ファイルスキップ
	JP	SD_USR_FIND_CONCAT_1BLOCK	; USR($D81B,F$) MZ2000_SD連結ファイル検索
	JP	SD_TOP_CONCAT			; USR($B81E)    MZ2000_SD連結ファイル先頭へシーク
	JP	SD_CLOSE_CONCAT			; USR($B821)    MZ2000_SD連結ファイルクローズ
	JP	DRAW_MMZ			; USR($B824)    SD_USR_OPEN_CONCATでOPEN済みの連結ファイル内のMMZ画像1画面分表示
	JP	SD_USR_NEXT_FILE_EXIST		; USR($B827,R$)	MZ2000_SD連結ファイルの次のデータがあるか
	JP	DRAW_MMZ_FILE			; USR($B82A,F$)	指定されたMMZファイルを読み込み画像1画面分表示
	RET
	NOP
	NOP					; USR($B82D)	未使用
	; WICS用
	LD	DE, 0A7E0h
	JP	SD_USR_OPEN_CONCAT		; WICS用 USR($B830,0)
	LD	DE, 0A7FFh
	JP	SD_USR_NEXT_FILE_EXIST		; WICS用 USR($B836,0)
	; BASIC EMM CALL ADDRESS
	JP	EMM_USR_OPEN_CONCAT		; USR($B83C,F$) MZ2000_SD連結ファイルオープン
	JP	EMM_USR_READ_CONCAT_1BLOCK	; USR($B83F)    MZ2000_SD連結ファイルロード
	JP	EMM_SKIP_CONCAT_1BLOCK		; USR($B842)    MZ2000_SD連結ファイルスキップ
	JP	EMM_USR_FIND_CONCAT_1BLOCK	; USR($B845,F$) MZ2000_SD連結ファイル検索
	JP	EMM_TOP_CONCAT			; USR($B848)    MZ2000_SD連結ファイル先頭へシーク
	JP	EMM_DRAW_MMZ			; USR($B84B)    SD_USR_OPEN_CONCATでOPEN済みの連結ファイル内のMMZ画像1画面分表示
	JP	EMM_USR_NEXT_FILE_EXIST		; USR($B84E,R$) MZ2000_SD連結ファイルの次のデータがあるか
	; WICS EMM用
	LD	DE, 0A7E0h
	JP	EMM_USR_OPEN_CONCAT		; WICS用 USR($B851,0)
	LD	DE, 0A7FFh
	JP	EMM_USR_NEXT_FILE_EXIST		; WICS用 USR($B857,0)
	; FONT
	JP	GET_LENGTH_BASIC		; C$=CHR$(ID):USR($B85D,C$) 文字数取得
	JP	DRAWFONT_ALL_BASIC		; C$=CHR$(X)+CHR$(Y)+CHR(C)+CHR$(R)+CHR$(ID):USR($B860,C$)
	JP	DRAWFONT_BASIC			; C$=CHR$(X)+CHR$(Y)+CHR(C)+CHR$(R)+CHR$(ID)+CHR$(I):USR($B863,C$)
	JP	ERASE_BASIC			; C$=CHR$(ID):USR($B866,C$)

; GVRAMにあるデータをRAMに転送する
; GVRAM to RAM 0C000h～ 16000bytes
; GRAPH Iで指定されているページがRAMに転送されます
GVRAMTORAM:
	LD	(RESTORE_STACK1 + 1), SP
	LD	SP, STACK - 1

	; backup port 0E8h
	IN	A, (0E8h)
	LD	(BACKUP_PORT_0E8), A

	; 125word(250byte) x 64 = 16000byte
	LD	HL, 0C000h
	LD	B, 64
LOOP1:
	; 0C000h～をGVRAMに切り替え
	IN	A, (0E8h)
	AND	030h
	OR	080h
	OUT	(0E8h), A

	; G-VRAM to stack 125word (250byte)
	LD	C, 125
LOOP2:
	LD	D, (HL)
	INC	HL
	LD	E, (HL)
	INC	HL
	PUSH	DE
	DEC	C
	JR	NZ, LOOP2

	; 0C000h～RAMに戻す
	LD	A, (BACKUP_PORT_0E8)
	OUT	(0E8h), A

	; Stack to RAM 125word (250byte)
	LD	C, 125
LOOP3:
	POP	DE
	DEC	HL
	LD	(HL), E
	DEC	HL
	LD	(HL), D
	DEC	C
	JR	NZ, LOOP3

	; HLを250byte進める
	LD	DE, 250
	ADD	HL, DE

	DEC	B
	JR	NZ, LOOP1

	; restore SP
RESTORE_STACK1:
	LD	SP, 0000
	RET

; RAMにあるデータをGVRAMに転送する
; RAM to GVRAM 0C000h～ 16000bytes
; RAMからGRAPH Iで指定されているページに転送されます
RAMTOGVRAM:
	LD	(RESTORE_STACK2 + 1), SP
	LD	SP, STACK - 1

	; backup port 0E8h
	IN	A, (0E8h)
	LD	(BACKUP_PORT_0E8), A

	; 125word(250byte) x 64 = 16000byte
	LD	HL, 0C000h
	LD	B, 64
LOOP4:
	; 0C000h～RAMに戻す
	LD	A, (BACKUP_PORT_0E8)
	OUT	(0E8h), A

	; G-VRAM to stack 125word (250byte)
	LD	C, 125
LOOP5:
	LD	D, (HL)
	INC	HL
	LD	E, (HL)
	INC	HL
	PUSH	DE
	DEC	C
	JR	NZ, LOOP5

	; 0C000h～をGVRAMに切り替え
	AND	030h
	OR	080h
	OUT	(0E8h), A

	; Stack to RAM (250byte)
	LD	C, 125
LOOP6:
	POP	DE
	DEC	HL
	LD	(HL), E
	DEC	HL
	LD	(HL), D
	DEC	C
	JR	NZ, LOOP6

	; HLを250byte進める
	LD	DE, 250
	ADD	HL, DE

	DEC	B
	JR	NZ, LOOP4

	; 0C000h～RAMに戻す
	LD	A, (BACKUP_PORT_0E8)
	OUT	(0E8h), A

	; restore SP
RESTORE_STACK2:
	LD	SP, 0000
	RET

; RAMにあるデータを幅2倍にしてGVRAMに転送する
; RAM to GVRAM 0C000h～ 8000bytes
; RAMからGRAPH Iで指定されているページに転送されます
RAMTOGVRAM_WIDTHX2:
	LD	(RESTORE_STACK3 + 1), SP
	LD	SP, STACK - 1

	; backup port 0E8h
	IN	A, (0E8h)
	LD	(BACKUP_PORT_0E8), A

	; 100word(200byte) x 40 = 8000byte
	LD	HL, 0C000h ; データ位置
	LD	IY, 0C000h ; 描画位置
	LD	B, 40
RAMTOGVRAM_WIDTHX2_LOOP4:
	; 0C000h～RAMに戻す
	LD	A, (BACKUP_PORT_0E8)
	OUT	(0E8h), A

	; G-VRAM to stack 100word (200byte)
	LD	C, 100
RAMTOGVRAM_WIDTHX2_LOOP5:
	LD	D, (HL)
	INC	HL
	LD	E, (HL)
	INC	HL
	PUSH	DE
	DEC	C
	JR	NZ, RAMTOGVRAM_WIDTHX2_LOOP5

	; 0C000h～をGVRAMに切り替え
	AND	030h
	OR	080h
	OUT	(0E8h), A

	LD	DE, 400
	ADD	IY, DE

	; Stack to RAM (200byte)
	LD	C, 100
RAMTOGVRAM_WIDTHX2_LOOP6:
	POP	DE
	DEC	IY
	DEC	IY
	LD	A, E
	CALL	PUT_WIDTHX2
	DEC	IY
	DEC	IY
	LD	A, D
	CALL	PUT_WIDTHX2
	DEC	C
	JR	NZ, RAMTOGVRAM_WIDTHX2_LOOP6
	; 描画位置を合わせるためIYを200byte進める
	LD	DE, 400
	ADD	IY, DE

	DEC	B
	JR	NZ, RAMTOGVRAM_WIDTHX2_LOOP4

	; 0C000h～RAMに戻す
	LD	A, (BACKUP_PORT_0E8)
	OUT	(0E8h), A

	; restore SP
RESTORE_STACK3:
	LD	SP, 0000
	RET

; IYの場所にAを16ビット拡張してセットする
PUT_WIDTHX2:
	PUSH	HL
	PUSH	BC
	; A左4ビット → H8ビット
	LD	B, 4
@@:
	SLA	A
	PUSH	AF
	RL	H
	POP	AF
	RL	H
	DJNZ	@b
	; A右4ビット → L8ビット
	LD	B, 4
@@:
	SLA	A
	PUSH	AF
	RL	L
	POP	AF
	RL	L
	DJNZ	@b
	LD	(IY), L
	INC	IY
	LD	(IY), H
	DEC	IY
	POP	BC
	POP	HL
	RET

; デコードする
; HL: lzeデータ + 4
DECORD:
	LD	DE, 09800h
	CALL	DECODE_LZE
	RET

BACKUP_PORT_0E8:
	DB	0

INCLUDE "lzdec.mac"
INCLUDE "MZ2000SD.ASM"
INCLUDE "EMM.ASM"
INCLUDE "MMZDECORD2000.ASM"
INCLUDE "FONT.ASM"

	ORG	0C000h
STACK:

	END	000B1h
