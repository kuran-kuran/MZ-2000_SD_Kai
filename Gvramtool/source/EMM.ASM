EMM_PORT_BASE	EQU	0A4h

; BASICからのEMM読み込み
; USR($xxxx, F$)
; DE: 文字列のアドレス
; BC: 文字列の長さ
EMM_USR_OPEN_CONCAT:
	CALL	EMM_OPEN_CONCAT
	RET

EMM_USR_READ_CONCAT_1BLOCK:
	CALL	EMM_READ_CONCAT_1BLOCK
	RET

EMM_USR_FIND_CONCAT_1BLOCK:
	LD	H, D
	LD	L, E
	CALL	EMM_FIND_CONCAT_1BLOCK
	RET

EMM_USR_NEXT_FILE_EXIST:
	CALL	EMM_NEXT_FILE_EXIST
	; 文字列の1バイト目にレスポンスを返す
	LD	(DE), A
	RET

; EMM操作
; 破壊 A
EMM_TOP_CONCAT:
EMM_OPEN_CONCAT:
	XOR	A
	OUT	(EMM_PORT_BASE), A
	OUT	(EMM_PORT_BASE + 1), A
	OUT	(EMM_PORT_BASE + 2), A
	LD	(MZT_HEADER_VALID), A
	RET

; 破壊 A, BC, HL
EMM_READ_CONCAT_1BLOCK:
	LD	A, (MZT_HEADER_VALID)
	OR	A
	JR	NZ, @f
	CALL	EMM_READ_HEADER
@@:
	CALL	EMM_READ_DATA
	XOR	A
	LD	(MZT_HEADER_VALID), A
	RET

; 破壊 A, BC, HL
EMM_SKIP_CONCAT_1BLOCK:
	LD	A, (MZT_HEADER_VALID)
	OR	A
	JR	NZ, @f
	CALL	EMM_READ_HEADER
@@:
	; ファイルを読み捨てる
	LD	BC, (MZT_SIZE)
@@:
	IN	A, (EMM_PORT_BASE + 3)
	DEC	BC
	LD	A, B
	OR	C
	JR	NZ, @b
	XOR	A
	LD	(MZT_HEADER_VALID), A
	RET

; 0Dhで終わっている文字列を比較する
; LD	DE, 比較文字列1, 0Dh
; LD	HL, 比較文字列2, 0Dh
; Result Cyフラグ (0: 違う, 1: 同じ)
; 破壊 A, DE, HL
CMP_TEXT:
CMP_TEXT_1:
	LD	A, (DE)
	CP	(HL)
	JR	NZ, CMP_TEXT_2
	CP	00Dh
	INC	DE
	INC	HL
	JR	NZ, CMP_TEXT_1
	SCF
	RET
CMP_TEXT_2:
	OR	A
	RET

; HL: Filename
; 破壊 A, BC, DE
EMM_FIND_CONCAT_1BLOCK:
	PUSH	HL
	LD	A, (MZT_HEADER_VALID)
	OR	A
	JR	NZ, @f
	CALL	EMM_READ_HEADER
@@:
	POP	HL
	; ファイル名が一緒か?
	LD	DE, MZT_FILENAME
	PUSH	HL
	CALL	CMP_TEXT
	POP	HL
	JR	C, EMM_FIND_CONCAT_1BLOCK_SAME_NAME ; ファイル名が一緒
	; ファイルを読み捨てる
	LD	BC, (MZT_SIZE)
@@:
	IN	A, (EMM_PORT_BASE + 3)
	DEC	BC
	LD	A, B
	OR	C
	JR	NZ, @b
	XOR	A
	LD	(MZT_HEADER_VALID), A
	JR	EMM_FIND_CONCAT_1BLOCK
EMM_FIND_CONCAT_1BLOCK_SAME_NAME:
	LD	A, 1
	LD	(MZT_HEADER_VALID), A
	RET

; 文字列の1バイト目にレスポンスを返す
; Result A: 0xFE:次のデータがある, 0x00:次のデータが無い(終了)
; 破壊 B, HL
EMM_NEXT_FILE_EXIST:
	LD	A, (MZT_HEADER_VALID)
	OR	A
	JR	NZ, @f
	CALL	EMM_READ_HEADER
	LD	A, 1
	LD	(MZT_HEADER_VALID), A
@@:
	LD	A, (MZT_MODE)
	OR	A
	JR	Z, @f
	CP	0FFh
	JR	Z, @f
	LD	A, 0FEh
@@:
	RET

; 破壊 A, B, HL
EMM_READ_HEADER:
	; 24バイト読み込む
	LD	HL, MZT_HEADER
	LD	B, 24
@@:
	IN	A, (EMM_PORT_BASE + 3)
	LD	(HL), A
	INC	HL
	DJNZ	@b
	; 104バイト読み飛ばす
	LD	B, 104
@@:
	IN	A, (EMM_PORT_BASE + 3)
	DJNZ	@b
	RET

; HL: Read buffer
; 破壊 A, BC, HL
EMM_READ_DATA:
	LD	BC, (MZT_SIZE)
	LD	HL, (MZT_ADDRESS)
@@:
	IN	A, (EMM_PORT_BASE + 3)
	LD	(HL), A
	INC	HL
	DEC	BC
	LD	A, B
	OR	C
	JR	NZ, @b
	RET

MZT_HEADER_VALID:
	DB	0
MZT_HEADER:
MZT_MODE:
	DB	0
MZT_FILENAME:
	DS	17
MZT_SIZE:
	DW	0
MZT_ADDRESS:
	DW	0
MZT_EXECUTE:
	DW	0
;MZT_RESERVED:
;	DS	104
